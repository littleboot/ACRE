# Keil uVision project T211110.uvprojx, settings and files
target T211110V01 (6160000::V6.16::ARMCLANG)
  device: GD32F103CB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: T211110.elf +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,HXTAL_VALUE=12000000
  c misc: -Wno-padded -Wno-covered-switch-default
  c include: ..\Include;..\Libraries\SSD1306_OLED_Display\include;..\Libraries\cli\include;.\RTE\_T211110V01;..\..\..\..\..\AppData\Local\Arm\Packs\ARM\CMSIS\5.8.0\CMSIS\Core\Include;..\..\..\..\..\AppData\Local\Arm\Packs\GigaDevice\GD32F10x_DFP\2.0.2\Device\Include;..\..\..\..\..\AppData\Local\Arm\Packs\GigaDevice\GD32F10x_DFP\2.0.2\Device\Firmware\Peripherals\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../Source/: gd32f10x_it.c systick.c system_gd32f10x.c i2c.c main.c
  group Startup
    ../Startup/: startup_gd32f10x_md.s
  group Libraries
    ../Libraries/SSD1306_OLED_Display/source/: ssd1306.c ssd1306_fonts.c
    ../Libraries/cli/source/: cli.c
software components: CMSIS:CORE 5.5.0, Device:GD32F10x_StdPeripherals:ADC 2.0.1, Device:GD32F10x_StdPeripherals:DBG 2.0.1, Device:GD32F10x_StdPeripherals:DMA 2.0.1, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FWDGT 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:I2C 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_StdPeripherals:WWDGT 2.0.1, Device:GD32F10x_libopt 2.0.1
