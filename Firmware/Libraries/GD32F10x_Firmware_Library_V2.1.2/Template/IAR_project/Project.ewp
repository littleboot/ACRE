# IAR project Project.ewp, settings and files
configuration GD32F10X_CL (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_CL
  ICCARM.CCIncludePath2: ..\; ..\..\Firmware\GD32F10x_standard_peripheral\Include; ..\..\Firmware\CMSIS; ..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\Firmware\CMSIS\GD; ..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F107xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration GD32F10X_MD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F103xB GD GD32F103xB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_MD
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F103xB.icf
configuration GD32F10X_HD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F103xC GD GD32F103xC
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_HD
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F103xC.icf
configuration GD32F10X_XD (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F103xK GD GD32F103xK
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_XD
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32F103xK.icf
  group Application
    ../: gd32f10x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group Peripherals
    ../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s startup_gd32f10x_hd.s startup_gd32f10x_md.s startup_gd32f10x_xd.s
  group Utilities
    ../../Utilities/: gd32f10x_eval.c
