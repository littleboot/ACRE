# Keil uVision project Project.uvproj, settings and files
target GD32F10X_CL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F107VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL
  c include: ..\inc;..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\..\Firmware\CMSIS;..\..\..\..\Utilities;..\lwip-2.0.2\src\include;..\lwip-2.0.2\port\GD32F10x\Basic;..\lwip-2.0.2\port\GD32F10x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: gd32f10x_enet_eval.c gd32f10x_it.c hello_gigadevice.c main.c netconf.c
  group CMSIS
    ../../../../Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group Peripherals
    ../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_wwdgt.c gd32f10x_usart.c gd32f10x_timer.c gd32f10x_spi.c gd32f10x_sdio.c gd32f10x_rtc.c gd32f10x_rcu.c gd32f10x_pmu.c gd32f10x_misc.c gd32f10x_i2c.c gd32f10x_gpio.c gd32f10x_fwdgt.c gd32f10x_fmc.c gd32f10x_exti.c gd32f10x_exmc.c gd32f10x_enet.c gd32f10x_dma.c gd32f10x_dbg.c gd32f10x_dac.c gd32f10x_crc.c gd32f10x_can.c gd32f10x_bkp.c gd32f10x_adc.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group LwIP-Port
    ../lwip-2.0.2/port/GD32F10x/Basic/: ethernetif.c
  group LwIP
    ../lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip-2.0.2/src/netif/: ethernet.c
  group Utilities
    ../../../../Utilities/: gd32f10x_eval.c
  group doc
    ../src/: readme.txt
