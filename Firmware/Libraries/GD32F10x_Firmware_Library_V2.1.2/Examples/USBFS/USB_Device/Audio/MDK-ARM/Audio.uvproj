# Keil uVision project Audio.uvproj, settings and files
target Audio (ARM-ADS)
  device: GD32F107VC GigaDevice
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: USBD_DFU +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USBFS,GD32F10X_CL
  c misc: --c99
  c include: ..\inc;..\..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\..\..\Firmware\GD32F10x_usbfs_driver\Include;..\..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application
    ../src/: app.c usb_delay.c gd32f10x_it.c audio_core.c gd3210c_audio_codec.c usbd_audio_out_if.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_StdPeriph_Driver
    ../../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_spi.c
  group GD32F10x_EVAL
    ../../../../../Utilities/: gd32f10x_eval.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group USB_Driver
    ../../../../../Firmware/GD32F10x_usbfs_driver/Source/: usbd_std.c usbd_int.c usbd_core.c usb_core.c
  group Doc
    ../: readme.txt
