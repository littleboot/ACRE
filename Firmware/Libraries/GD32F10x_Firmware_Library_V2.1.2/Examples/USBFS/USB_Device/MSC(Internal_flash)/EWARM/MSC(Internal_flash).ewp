# IAR project MSC(Internal_flash).ewp, settings and files
configuration USBFS (ARM, debug)
  General.OGChipSelectEditMenu: GD32F107xC GD GD32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_USBFS; GD32F10X_CL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Utilities; ..\..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include; ..\..\..\..\..\Firmware\GD32F10x_usbfs_driver\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: HID_MSC(Internal_sram).hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../src/: app.c gd32f10x_it.c usb_delay.c usbd_bbb_scsi.c usbd_flash_access.c usbd_msc_core.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F10X_EVAL
    ../../../../../Utilities/: gd32f10x_eval.c
  group GD32F10X_StdPeriph
    ../../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_cl.s
  group USB_Drivers
    ../../../../../Firmware/GD32F10x_usbfs_driver/Source/: usb_core.c usbd_core.c usbd_int.c usbd_std.c
