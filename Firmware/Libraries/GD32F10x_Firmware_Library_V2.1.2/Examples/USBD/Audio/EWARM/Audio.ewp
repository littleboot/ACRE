# IAR project Audio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F103xC GD GD32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F10X_HD
  ICCARM.CCIncludePath2: ..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include; ..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include; ..\..\..\..\Firmware\GD32F10x_usbd_driver\Include; ..\inc; ..\..\..\..\Utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CDC_ACM.srec
  ILINK.IlinkOutputFile: CDC_ACM.hex
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appliction
    ../src/: audio_core.c gd32f103c_audio_codec.c gd32f10x_it.c main.c usbd_audio_out_if.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group Doc
    ../: readme.txt
  group GD32F10x_EVAL
    ../../../../Utilities/: gd32f10x_eval.c
  group GD32F10x_Peripherals
    ../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_dma.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F10x/Source/IAR/: startup_gd32f10x_hd.s
  group USB_Driver
    ../../../../Firmware/GD32F10x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
