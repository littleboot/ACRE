# Keil uVision project Audio.uvproj, settings and files
target USBD_Audio (ARM-ADS)
  device: GD32F103VC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Audio +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER GD32F10X_HD
  c misc: --c99
  c include: ..\..\..\..\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\..\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\..\Firmware\GD32F10x_usbd_driver\Include;..\inc;..\..\..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Appliction
    ../src/: main.c gd32f10x_it.c audio_core.c usbd_audio_out_if.c gd32f103c_audio_codec.c
  group CMSIS
    ../src/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../../Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_spi.c
  group GD3210x_EVAL
    ../../../../Utilities/: gd32f10x_eval.c
  group Startup
    ../../../../Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group USBD_Drivers
    ../../../../Firmware/GD32F10x_usbd_driver/Source/: usbd_core.c usbd_int.c usbd_pwr.c usbd_std.c
  group Doc
    ../: readme.txt
